# IAR project esOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_LD
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\src\flashloader\ST\FlashSTM32F10x\inc; $TOOLKIT_DIR$\src\flashloader\ST\FlashSTM32F3xx\inc; $TOOLKIT_DIR$\src\flashloader\ST\FlashSTM32F0xx\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: esOS.c esOS_CPU.s main.c startup_stm32f10x_ld.s SysTick.c
